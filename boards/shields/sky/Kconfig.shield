## boards/shields/sky/Kconfig.shield
```kconfig
config SKY_LEFT
    def_bool $(shields_list_contains, sky_left)

config SKY_RIGHT
    def_bool $(shields_list_contains, sky_right)
```
